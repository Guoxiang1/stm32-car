# Keil uVision project BST.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BST +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CORE;..\HARDWARE\adc;..\HARDWARE\iic;..\HARDWARE\led;..\HARDWARE\motor;..\HARDWARE\MPU6050;..\HARDWARE\timer;..\HARDWARE\UltrasonicWave;..\HARDWARE;..\LIB\inc;..\SYS\delay;..\SYS\sys;..\SYS\usart;..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group HARDWARE
    ../HARDWARE/adc/: adc.c
    ../HARDWARE/iic/: I2C.c I2C_MPU6050.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/UltrasonicWave/: UltrasonicWave.c
    ../HARDWARE/: MPU6050.c OUTPUTDATA.c systick.c upstandingcar.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYS
    ../SYS/delay/: delay.c
    ../SYS/sys/: sys.c
    ../SYS/usart/: usart.c
